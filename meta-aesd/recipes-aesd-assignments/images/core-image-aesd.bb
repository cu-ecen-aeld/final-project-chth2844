
inherit core-image
IMAGE_INSTALL:append = " aesd-assignments"
#inherit extrausers
#EXTRA_USERS_PARAMS = "usermod -P root root;"
